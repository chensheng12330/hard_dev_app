# Keil uVision project HC595CP.uvproj, settings and files
target HC595CP (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: HC595CP +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: HC595CP.c
